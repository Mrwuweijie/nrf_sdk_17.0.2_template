# Keil uVision project nrf_template.uvprojx, settings and files
target nRF52_softdevice_sxxx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf_template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_link_ctx_manager;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\atomic_flags;..\components\libraries\balloc;..\components\libraries\bootloader\ble_dfu;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\crypto;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\delay;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\experimental_task_manager;..\components\libraries\fds;..\components\libraries\fifo;..\components\libraries\fstorage;..\components\libraries\gfx;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\memobj;..\components\libraries\mpu;..\components\libraries\mutex;..\components\libraries\pwm;..\components\libraries\pwr_mgmt;..\components\libraries\queue;..\components\libraries\ringbuf;..\components\libraries\scheduler;..\components\libraries\sdcard;..\components\libraries\slip;..\components\libraries\sortlist;..\components\libraries\spi_mngr;..\components\libraries\stack_guard;..\components\libraries\strerror;..\components\libraries\svc;..\components\libraries\timer;..\components\libraries\twi_mngr;..\components\libraries\twi_sensor;..\components\libraries\uart;..\components\libraries\util;..\components\softdevice\common;..\components\softdevice\s140\headers;..\components\softdevice\s140\headers\nrf52;..\external\fprintf;..\external\segger_rtt;..\external\utf_converter;..\integration\nrfx;..\integration\nrfx\legacy;..\modules\nrfx;..\modules\nrfx\drivers\include;..\modules\nrfx\hal;.\Sources;.\Sources\application;.\Sources\drivers;.\Sources\libraries;.\Sources\modules
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ./Sources/application/: main.c
    ./Sources/: sdk_config.h usr_config.h
  group Modules
    ./Sources/modules/: m_ble.c m_ble_advertising.c m_coms.c
  group Drivers
    ./Sources/drivers/: drv_key_scan.c drv_led_blink.c drv_dht11.c drv_sensor_bh1750.c drv_saadc_det.c
  group Board Definition
    ../components/boards/: boards.c
  group Board Support
    ../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ../external/utf_converter/: utf.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_twim.c nrfx_saadc.c
    ../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c nrf_drv_twi.c
    ../modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../components/libraries/atomic_flags/: nrf_atflags.c
    ../components/libraries/atomic/: nrf_atomic.c
    ../components/libraries/balloc/: nrf_balloc.c
    ../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../components/libraries/memobj/: nrf_memobj.c
    ../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../components/libraries/ringbuf/: nrf_ringbuf.c
    ../components/libraries/sortlist/: nrf_sortlist.c
    ../components/libraries/strerror/: nrf_strerror.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
  group nRF_Log
    ../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0, Device:StartupConfig 8.35.0
